## l6/l6_e2_sol/build/Kconfig/boards/Kconfig.thingy53
```kconfig
# Load board Kconfig descriptions.
osource "C:/ncs/v3.4.0/zephyr/boards/nordic/thingy53/Kconfig.thingy53"
```
